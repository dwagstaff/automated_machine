# Keil uVision project antfs_client.uvproj, settings and files
target nrf51422_xxaa (256K) (ARM-ADS)
  device: nRF51422_xxAA Nordic
  cpu: IRAM(0x20000800-0x20003FFF) IROM(0xA000-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: antfs_client +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: NRF51 BOARD_PCA10003 DEBUG_NRF TRACE_MEM_WRITE_OFF
  c misc: --diag-suppress=3017 --c99
  c include: ..\..\..\..\..\..\Include;..\..\..\..\..\..\Include\app_common;..\include;..\..\..\..\..\..\Include\ant\softdevice;..\..\..\..\..\..\Include\ant
  memory RVCT4: ROM 0x0000A000 size 0x00036000
  memory RVCT9: RAM 0x20000800 size 0x00003800
  group src
    ../: main.c retarget.c antfs.c mem.c crc.c leddriver.c
  group core
    ../../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ../../../../../../Source/templates/: system_nrf51422.c
  group modules
    ../../../../../../Source/app_common/: app_button.c app_fifo.c app_gpiote.c app_timer.c app_uart_fifo.c
