# Keil uVision project spi_master_example.uvproj, settings and files
target nrf51422_xxaa (256K) (ARM-ADS)
  device: nRF51422_xxAA Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: spi_master_example_arm +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51
  c misc: --c99
  c include: ..\..\..\..\Include;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0000A000 size 0x00036000
  memory RVCT9: RAM 0x20000800 size 0x00003800
  group app
    ../: main.c
    ../../../../Source/: keil_arm_uv4.lnt
  group core
    ../../../../Source/templates/arm/: arm_startup_nrf51.s
    ../../../../Source/templates/: system_nrf51.c
  group lib
    ../../../../Source/spi_master/: spi_master.c
    ../../../../Source/nrf_delay/: nrf_delay.c
