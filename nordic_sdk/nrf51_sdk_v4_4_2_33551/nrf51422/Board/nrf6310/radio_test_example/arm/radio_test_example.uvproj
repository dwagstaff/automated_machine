# Keil uVision project radio_test_example.uvproj, settings and files
target nrf51422_xxaa (256K) (ARM-ADS)
  device: nRF51422_xxAA Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: radio_test_example +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BOARD_NRF6310
  c misc: --c99
  c include: ..\..\..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0000A000 size 0x00036000
  memory RVCT9: RAM 0x20000800 size 0x00003800
  group app
    ../../../../Source/: keil_arm_uv4.lnt
    ../: main.c radio_test.c uart.c
  group core
    ../../../../Source/templates/arm/: arm_startup_nrf51.s
    ../../../../Source/templates/: system_nrf51.c
