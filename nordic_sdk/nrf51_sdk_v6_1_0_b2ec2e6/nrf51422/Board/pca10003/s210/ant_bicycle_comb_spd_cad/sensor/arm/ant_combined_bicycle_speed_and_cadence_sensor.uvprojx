# Keil uVision project ant_combined_bicycle_speed_and_cadence_sensor.uvprojx, settings and files
target nrf51422_xxaa (256K) (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: IRAM(0x20000800-0x20003FFF) IROM(0xA000-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ant_combined_bicycle_speed_and_cadence_sensor +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: NRF51 BOARD_PCA10003 TRACE_UART
  c misc: --c99
  c include: ..\..\..\..\..\..\Include;..\..\..\..\..\..\Include\app_common;..\include;..\..\..\..\..\..\Include\s210;..\..\..\..\..\..\Include\sd_common
  memory RVCT4: ROM 0xc000 size 0x34000
  memory RVCT9: RAM 0x20000900 size 0x3700
  group src
    ../: main.c retarget.c main_cbsc_tx.c cbsc_tx.c
  group libraries
    ../../../../../../Source/app_common/: app_timer.c app_uart_fifo.c app_fifo.c app_gpiote.c
  group ::Device
    RTE/Device/nRF51422_xxAA/: arm_startup_nrf51.s system_nrf51.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
