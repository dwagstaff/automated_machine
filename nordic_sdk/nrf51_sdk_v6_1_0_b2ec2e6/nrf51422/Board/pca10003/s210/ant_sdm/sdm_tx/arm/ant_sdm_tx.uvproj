# Keil uVision project ant_sdm_tx.uvproj, settings and files
target nrf51422_xxaa_s210 (256K) (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000800-0x20003FFF) IROM(0xA000-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ant_sdm_tx +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: NRF51 BOARD_PCA10003 TRACE_GPIO TRACE_UART
  c misc: --c99
  c include: ..\..\..\..\..\..\Include;..\..\..\..\..\..\Include\app_common;..\include;..\..\..\..\..\..\Include\s210;..\..\..\..\..\..\Include\sd_common
  memory RVCT4: ROM 0x0000C000 size 0x00034000
  memory RVCT9: RAM 0x20000900 size 0x00003700
  group src
    ../: main.c sdm_tx.c timer.c retarget.c
  group core
    ../../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ../../../../../../Source/templates/: system_nrf51422.c
  group libraries
    ../../../../../../Source/app_common/: app_fifo.c app_gpiote.c app_uart_fifo.c
