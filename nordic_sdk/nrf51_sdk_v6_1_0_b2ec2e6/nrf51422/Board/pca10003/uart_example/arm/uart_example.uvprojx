# Keil uVision project uart_example.uvprojx, settings and files
target nrf51422_xxaa (256K) (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: uart_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_PCA10003
  c include: ..\..\..\..\Include
  memory RVCT4: ROM 0x00000000 size 0x00040000
  memory RVCT9: RAM 0x20000000 size 0x00004000
  group app
    ../: main.c
  group ::DEVICE
    RTE/Device/nRF51422_xxAA/: system_nrf51.c startup_arm_nrf51.s
  group lib
    ../../../../Source/simple_uart/: simple_uart.c
target nrf51422_xxaa_s210 (256K) (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: uart_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_PCA10003
  c include: ..\..\..\..\Include
  memory RVCT4: ROM 0x0000C000 size 0x00034000
  memory RVCT9: RAM 0x20000900 size 0x00003700
target nrf51422_xxaa_s310 (256K) (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: uart_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_PCA10003
  c include: ..\..\..\..\Include
  memory RVCT4: ROM 0x00020000 size 0x0001F000
  memory RVCT9: RAM 0x20002400 size 0x00001C00
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
