# Keil uVision project blinky.uvprojx, settings and files
target nrf51422_xxaa (256K) (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: blinky_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_PCA10003
  c include: ..\..\..\..\Include
  memory RVCT4: ROM 0x00000000 size 0x00040000
  memory RVCT9: RAM 0x20000000 size 0x00004000
  group app
    ../: main.c
    ../../../../Source/: keil_arm_uv4.lnt
  group ::DEVICE
    RTE/Device/nRF51422_xxAA/: startup_arm_nrf51.s system_nrf51.c
  group lib
    ../../../../Source/nrf_delay/: nrf_delay.c
target nrf51422_xxaa_s210 (256K) (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: blinky_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_PCA10003
  c include: ..\..\..\..\Include
  memory RVCT4: ROM 0x0000C000 size 0x00034000
  memory RVCT9: RAM 0x20000900 size 0x00003700
target nrf51422_xxaa_s310 (256K) (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: blinky_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_PCA10003
  c include: ..\..\..\..\Include
  memory RVCT4: ROM 0x00020000 size 0x0001F000
  memory RVCT9: RAM 0x20002400 size 0x00001C00
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
