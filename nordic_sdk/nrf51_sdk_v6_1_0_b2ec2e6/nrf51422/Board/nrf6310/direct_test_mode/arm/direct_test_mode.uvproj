# Keil uVision project direct_test_mode.uvproj, settings and files
target nrf51422_xxaa (256K) (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: direct_test_mode +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: NRF51 BOARD_NRF6310
  c misc: --c99
  c include: ..\..\..\..\Include\ble;..\..\..\..\Include
  asm misc: --cpreproc --cpreproc_opts='-DASSEMBLER_PREPROC__'
  memory RVCT4: ROM 0x00000000 size 0x00040000
  memory RVCT9: RAM 0x20000000 size 0x00004000
  link misc: --remove
  group Startup Code
    ../../../../Source/templates/: system_nrf51.c
    ../../../../Source/templates/arm/: arm_startup_nrf51.s
  group Source Code
    ../: main.c
  group Libraries
    ../../../../Source/ble/: ble_dtm.c
target nrf51422_xxaa_s210 (256K) (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  cpu: as above
  output: direct_test_mode +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: NRF51 BOARD_NRF6310
  c misc: --c99
  c include: ..\..\..\..\Include\ble;..\..\..\..\Include
  asm misc: --cpreproc --cpreproc_opts='-DASSEMBLER_PREPROC__'
  memory RVCT4: ROM 0x0000C000 size 0x00034000
  memory RVCT9: RAM 0x20000900 size 0x00003700
  link misc: --remove
target nrf51422_xxaa_s310 (256K) (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  cpu: as above
  output: direct_test_mode +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: NRF51 BOARD_NRF6310
  c misc: --c99
  c include: ..\..\..\..\Include\ble;..\..\..\..\Include
  asm misc: --cpreproc --cpreproc_opts='-DASSEMBLER_PREPROC__'
  memory RVCT4: ROM 0x00020000 size 0x0001F000
  memory RVCT9: RAM 0x20002400 size 0x00001C00
  link misc: --remove
