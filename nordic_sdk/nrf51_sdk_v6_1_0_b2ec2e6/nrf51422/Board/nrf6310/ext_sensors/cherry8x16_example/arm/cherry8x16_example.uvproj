# Keil uVision project cherry8x16_example.uvproj, settings and files
target nrf51422_xxaa (256K) (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: cherry8x16_example_arm +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51
  c misc: --c99
  c include: ..\..\..\..\..\Include;..\..\..\..\..\Include\ext_sensors
  library: MicroLIB
  memory RVCT4: ROM 0x00000000 size 0x00040000
  memory RVCT9: RAM 0x20000000 size 0x00004000
  group app
    ../: main.c
    ../../../../../Source/: keil_arm_uv4.lnt
  group core
    ../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ../../../../../Source/templates/: system_nrf51.c
  group lib
    ../../../../../Source/ext_sensors/cherry8x16/: cherry8x16.c
    ../../../../../Source/simple_uart/: simple_uart.c
    ../../../../../Source/nrf_delay/: nrf_delay.c
target nrf51422_xxaa_s210 (256K) (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  cpu: as above
  output: cherry8x16_example_arm +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51
  c misc: --c99
  c include: ..\..\..\..\..\Include;..\..\..\..\..\Include\ext_sensors
  library: MicroLIB
  memory RVCT4: ROM 0x0000C000 size 0x00034000
  memory RVCT9: RAM 0x20000900 size 0x00003700
target nrf51422_xxaa_s310 (256K) (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  cpu: as above
  output: cherry8x16_example_arm +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51
  c misc: --c99
  c include: ..\..\..\..\..\Include;..\..\..\..\..\Include\ext_sensors
  library: MicroLIB
  memory RVCT4: ROM 0x00020000 size 0x0001F000
  memory RVCT9: RAM 0x20002400 size 0x00001C00
