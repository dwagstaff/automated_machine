# Keil uVision project app_lwip_udp_client_nrf6310.uvproj, settings and files
target nrf51422_xxaa_s1xx_iot (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxaa_s1xx_iot +hex
  c flags: Optim=4 OneElfS=1
  c define: NRF51 BOARD_NRF6310 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT
  c misc: --c99
  c include: ..\..\..\..\..\..\components\toolchain;..\..\..\..\..\bsp;..\..\..\;..\..\..\..\..\..\components\softdevice\s1xx_iot\headers;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\external\lwip\src\include;..\..\..\..\..\..\external\lwip\src\include\ipv4;..\..\..\..\..\..\external\lwip\src\include\ipv6;..\..\..\..\..\..\external\lwip\src\include\netif;..\..\..\..\..\..\external\lwip\src\port;..\..\..\..\..\..\external\lwip\src\port\arch;..\..\..\..\..\..\components\ble\ble_6lowpan;..\..\..\..\..\..\components\iot\include;..\..\..\..\..\..\components\ble\ble_services\ble_ipsp;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\components\libraries\trace;..\..\..\..\..\..\components\drivers_nrf\simple_uart;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\components\iot\context_manager;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\util
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x00018000 size 0x2B000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Application
    ../../../: main.c
  group BLE 6LoWPAN
    ../../../../../../components/ble/ble_6lowpan/lib/: ble_6lowpan.lib
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../../../../: Abstract.txt license.txt
  group IoT
    ../../../../../../components/iot/context_manager/: iot_context_manager.c
  group lwIP Stack
    ../../../../../../external/lwip/lib/: liblwip.lib
    ../../../../../../external/lwip/: license.txt
    ../../../../../../external/lwip/src/port/: nrf_platform_port.c
  group nRF_BLE_Modules
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../../components/drivers_nrf/simple_uart/: simple_uart.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/gpiote/: app_gpiote.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../components/libraries/mem_manager/: mem_manager.c
  group nRF_SoftDevice_Internal
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
target nrf51822_xxaa_s1xx_iot (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: as above
  output: nrf51822_xxaa_s1xx_iot +hex
  c flags: Optim=4 OneElfS=1
  c define: as above
  c misc: --c99
  c include: as above
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x00018000 size 0x2B000
  memory RVCT9: RAM 0x20002000 size 0x2000
